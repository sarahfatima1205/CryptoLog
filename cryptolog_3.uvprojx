# Keil uVision project cryptolog_3.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: cryptolog_3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -std=gnu99
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c crypto.c uart_cmd.c uart_hw.h crypto.h blockchain.c blockchain.h uart_cmd.h bignum.c bignum.h ecc.c ecc.h sensor_sim.c sensor_sim.h sha256.c sha256.h uart_hw.c
software components: CMSIS:CORE 6.2.0, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:DMA2D 1.7.13, Device:STM32Cube HAL:EXTI 1.7.13, Device:STM32Cube HAL:Flash 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:HCD 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:I2S 1.7.13, Device:STM32Cube HAL:IRDA 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:UART 1.7.13, Device:STM32Cube HAL:USART 1.7.13, Device:Startup 2.6.3
